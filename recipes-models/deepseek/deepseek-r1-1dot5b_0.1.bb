require deepseek-r1.inc

MODEL_TAG = "1.5b"

MANIFEST_SHA256 = "a42b25d8c10a841bd24724309898ae851466696a7d7f3a0a408b895538ccbc96"
IMAGE_JSON_SHA256 = "a85fe2a2e58e2426116d3686dfdc1a6ea58640c1e684069976aa730be6c1fa01"
MODEL_SHA256 = "aabd4debf0c8f08881923f2c25fc0fdeed24435271c2b3e92c4af36704040dbc"
