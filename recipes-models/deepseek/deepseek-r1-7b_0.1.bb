require deepseek-r1.inc

MODEL_TAG = "7b"

MANIFEST_SHA256 = "0a8c266910232fd3291e71e5ba1e058cc5af9d411192cf88b6d30e92b6e73163"
IMAGE_JSON_SHA256 = "40fb844194b25e429204e5163fb379ab462978a262b86aadd73d8944445c09fd"
MODEL_SHA256 = "96c415656d377afbff962f6cdb2394ab092ccbcbaab4b82525bc4ca800fe8a49"
