MODEL_TAG = "1b"

require llama3.2.inc

SRC_URI:remove = "${OLLAMA_URI}/blobs/sha256-${PARAMS_SHA256};name=params;"

MANIFEST_SHA256 = "baf6a787fdffd633537aa2eb51cfd54cb93ff08e28040095462bb63daf552878"
IMAGE_JSON_SHA256 = "4f659a1e86d7f5a33c389f7991e7224b7ee6ad0358b53437d54c02d2e1b1118d"
MODEL_SHA256 = "74701a8c35f6c8d9a4b91f3f3497643001d63e0c7a84e085bed452548fa88d45"
