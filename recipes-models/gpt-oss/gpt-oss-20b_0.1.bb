require gpt-oss.inc

MODEL_TAG = "20b"

PARAMS_SHA256 = "d8ba2f9a17b3bbdeb5690efaa409b3fcb0b56296a777c7a69c78aa33bbddf182"
LICESE_SHA256 = "f60356777647e927149cbd4c0ec1314a90caba9400ad205ddc4ce47ed001c2d6"
TEMPLATE_SHA256 = "fa6710a93d78da62641e192361344be7a8c0a1c3737f139cf89f20ce1626b99c"
MANIFEST_SHA256 = "17052f91a42e97930aa6e28a6c6c06a983e6a58dbb00434885a0cf5313e376f7"
IMAGE_JSON_SHA256 = "776beb3adb235076157cfea408b8ea2a2d25eae99d7f5da997f607f6b69fa0fa"
MODEL_SHA256 = "e7b273f9636059a689e3ddcab3716e4f65abe0143ac978e46673ad0e52d09efb"
