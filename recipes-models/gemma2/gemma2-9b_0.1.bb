require gemma2.inc

MODEL_TAG = "9b"

TEMPLATE_SHA256 = "109037bec39c0becc8221222ae23557559bc594290945a2c4221ab4f303b8871"
MANIFEST_SHA256 = "ff02c3702f322b9e075e9568332d96c0a7028002f1a5a056e0a6784320a4db0b"
IMAGE_JSON_SHA256 = "10aa81da732eae8a66e07d70620089a608f546ff280a2856a43be69d622f715a"
MODEL_SHA256 = "ff1d1fc78170d787ee1201778e2dd65ea211654ca5fb7d69b5a2e7b123a50373"
