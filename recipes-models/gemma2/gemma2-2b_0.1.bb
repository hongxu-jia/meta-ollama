require gemma2.inc

MODEL_TAG = "2b"

TEMPLATE_SHA256 = "e0a42594d802e5d31cdc786deb4823edb8adff66094d49de8fffe976d753e348"
MANIFEST_SHA256 = "8ccf136fdd5298f3ffe2d69862750ea7fb56555fa4d5b18c04e3fa4d82ee09d7"
IMAGE_JSON_SHA256 = "e18ad7af7efbfaecd8525e356861b84c240ece3a3effeb79d2aa7c0f258f71bd"
MODEL_SHA256 = "7462734796d67c40ecec2ca98eddf970e171dbb6b370e43fd633ee75b69abe1b"
