require qwen3.inc

MODEL_TAG = "8b"

TEMPLATE_SHA256 = "ae370d884f108d16e7cc8fd5259ebc5773a0afa6e078b11f4ed7e39a27e0dfc4"
MANIFEST_SHA256 = "500a1f067a9f782620b40bee6f7b0c89e17ae61f686b92c24933e4ca4b2b8b41"
IMAGE_JSON_SHA256 = "05a61d37b08453e59290add468e3bb2f688e23a01e967fecb0e2fa41218cea76"
MODEL_SHA256 = "a3de86cd1c132c822487ededd47a324c50491393e6565cd14bafa40d0b8e686f"
