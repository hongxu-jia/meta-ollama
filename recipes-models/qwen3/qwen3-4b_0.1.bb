require qwen3.inc

MODEL_TAG = "4b"

TEMPLATE_SHA256 = "2d54db2b9bb29ce7db54fea63a891f5859603813c555b1f88b5e0994652897f9"
MANIFEST_SHA256 = "359d7dd4bcdab3d86b87d73ac27966f4dbb9f5efdfcc75d34a8764a09474fae7"
IMAGE_JSON_SHA256 = "e18a783aae5525fd2852fc94c985541a77e791e034abc2d3056474d59de336fc"
MODEL_SHA256 = "3e4cb14174460404e7a233e531675303b2fbf7749c02f91864fe311ab6344e4f"
