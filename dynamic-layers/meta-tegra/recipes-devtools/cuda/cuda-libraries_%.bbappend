CUDA_COMPONENTS:remove:x86-64 = "libcudla"

